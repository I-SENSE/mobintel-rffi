options:
  parameters:
    generate_options: no_gui
    id: receive_capture
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_file
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(cap_len*rx_samp_rate)
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(skip*rx_samp_rate)
    type: complex
  states: {}
- name: cap_len
  id: parameter
  parameters:
    label: cap_len
    type: eng_float
    value: '0.512'
  states: {}
- name: device
  id: parameter
  parameters:
    label: '"device"'
    type: str
    value: '"addr=192.168.10.2"'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import uhd
  states: {}
- name: output_file
  id: parameter
  parameters:
    label: output_file
    type: str
    value: '"/root/received_samples.dat"'
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    label: rx_freq
    type: eng_float
    value: 2462e6
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: rx_gain
    type: eng_float
    value: '0.5'
  states: {}
- name: rx_lo_off
  id: parameter
  parameters:
    label: rx_lo_off
    type: eng_float
    value: 10e6
  states: {}
- name: rx_samp_rate
  id: parameter
  parameters:
    label: rx_samp_rate
    type: eng_float
    value: 25e6
  states: {}
- name: skip
  id: parameter
  parameters:
    label: skip
    type: eng_float
    value: '2'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    center_freq0: uhd.tune_request(rx_freq,rx_lo_off)
    dc_offs_enb0: 'true'
    dev_addr: args
    dev_args: '""'
    gain0: rx_gain
    iq_imbal_enb0: 'true'
    samp_rate: rx_samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [uhd_usrp_source_0, '0', blocks_skiphead_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
