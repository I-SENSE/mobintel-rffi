options:
  parameters:
    generate_options: qt_gui
    id: wifi_4usrp_native
    output_language: python
    title: mMIMO Capture
  states: {}

blocks:
- name: file_sink_enabled
  id: variable_qtgui_chooser
  parameters:
    label0: '0'
    label1: '1'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2442e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import os\nimport numpy as np\nfrom gnuradio import gr\n\nMAX_SAMP_PER_RECORD = 20e6 * 2 # store 2 seconds per stream\n\nclass blk(gr.sync_block):\n    def __init__(self, save_enabled=0, directory=\"/root/rec\", usrp_1=\"24-5_A.bin\", usrp_2=\"24-5_B.bin\", usrp_3=\"24-6_A.bin\", usrp_4=\"24-6_B.bin\"):\n        gr.sync_block.__init__(self,\n                               name=\"custom_block\",\n                               in_sig=[np.complex64, np.complex64, np.complex64, np.complex64],\n                               out_sig=None)\n\n        self.save_enabled = save_enabled\n        self.directory = directory\n        self.file_names = [usrp_1, usrp_2, usrp_3, usrp_4]\n        self.file_paths = [os.path.join(self.directory, usrp) for usrp in self.file_names]\n        self.file_handles = [None] * 4\n        self.file_check_counter = 0\n\n        self.sample_counter = [0] * 4 # we'll keep track of how many samples are we saving, to stop when >= MAX_SAMP_PER_RECORD\n\n        self.open_files()\n\n    def open_files(self, force_reopen=False):\n        if not os.path.exists(self.directory):\n            os.makedirs(self.directory)\n    \n        for i, file_path in enumerate(self.file_paths):\n            if force_reopen or not os.path.exists(file_path):\n                if self.file_handles[i] is not None:\n                    self.file_handles[i].close()\n                self.file_handles[i] = open(file_path, 'ab')\n\n    def write_samples(self, input_items, index):\n        self.sample_counter[index] = self.sample_counter[index] + len(input_items[index])\n        if self.file_handles[index] is not None:\n            self.file_handles[index].write(input_items[index].tobytes())\n\n    def work(self, input_items, output_items):\n        if self.save_enabled:\n            if self.file_check_counter % 1000 == 0:  # Adjust the frequency of file checks as needed\n                self.open_files(force_reopen=False)\n\n            self.file_check_counter += 1\n                \n            if self.sample_counter[0] >= MAX_SAMP_PER_RECORD:\n                self.save_enabled = 0\n                self.sample_counter = [0] * 4\n                print(\"2 seconds of samples recorded. Done.\")\n\n            for i in range(4):\n                self.write_samples(input_items, i)\n\n        return len(input_items[0])\n\n    def __del__(self):\n        for f in self.file_handles:\n            if f:\n                f.close()\n\n"
    directory: '''/root/rec'''
    save_enabled: file_sink_enabled
    usrp_1: '''24-5_A.bin'''
    usrp_2: '''24-5_B.bin'''
    usrp_3: '''24-6_A.bin'''
    usrp_4: '''24-6_B.bin'''
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import os\nimport numpy as np\nfrom gnuradio import gr\n\nMAX_SAMP_PER_RECORD = 20e6 * 2 # store 2 seconds per stream\n\nclass blk(gr.sync_block):\n    def __init__(self, save_enabled=0, directory=\"/root/rec\", usrp_1=\"24-5_A.bin\", usrp_2=\"24-5_B.bin\", usrp_3=\"24-6_A.bin\", usrp_4=\"24-6_B.bin\", usrp_5=\"24-7_A.bin\", usrp_6=\"24-7_B.bin\", usrp_7=\"24-8_A.bin\", usrp_8=\"24-8_B.bin\"):\n        gr.sync_block.__init__(self,\n                               name=\"custom_block\",\n                               in_sig=[np.complex64, np.complex64, np.complex64, np.complex64, np.complex64, np.complex64, np.complex64, np.complex64],\n                               out_sig=None)\n\n        self.save_enabled = save_enabled\n        self.directory = directory\n        self.file_names = [usrp_1, usrp_2, usrp_3, usrp_4, usrp_5, usrp_6, usrp_7, usrp_8]\n        self.file_paths = [os.path.join(self.directory, usrp) for usrp in self.file_names]\n        self.file_handles = [None] * 8\n        self.file_check_counter = 0\n\n        self.sample_counter = [0] * 8 # we'll keep track of how many samples are we saving, to stop when >= MAX_SAMP_PER_RECORD\n\n        self.open_files()\n\n    def open_files(self, force_reopen=False):\n        if not os.path.exists(self.directory):\n            os.makedirs(self.directory)\n    \n        for i, file_path in enumerate(self.file_paths):\n            if force_reopen or not os.path.exists(file_path):\n                if self.file_handles[i] is not None:\n                    self.file_handles[i].close()\n                self.file_handles[i] = open(file_path, 'ab')\n\n    def write_samples(self, input_items, index):\n        self.sample_counter[index] = self.sample_counter[index] + len(input_items[index])\n        if self.file_handles[index] is not None:\n            self.file_handles[index].write(input_items[index].tobytes())\n\n    def work(self, input_items, output_items):\n        if self.save_enabled:\n            if self.file_check_counter % 1000 == 0:  # Adjust the frequency of file checks as needed\n                self.open_files(force_reopen=False)\n\n            self.file_check_counter += 1\n                \n            if self.sample_counter[0] >= MAX_SAMP_PER_RECORD:\n                self.save_enabled = 0\n                self.sample_counter = [0] * 8\n                print(\"2 seconds of samples recorded. Done.\")\n\n            for i in range(8):\n                self.write_samples(input_items, i)\n\n        return len(input_items[0])\n\n    def __del__(self):\n        for f in self.file_handles:\n            if f:\n                f.close()\n\n"
    directory: '''/root/rec'''
    save_enabled: file_sink_enabled
    usrp_1: '''24-5_A.bin'''
    usrp_2: '''24-5_B.bin'''
    usrp_3: '''24-6_A.bin'''
    usrp_4: '''24-6_B.bin'''
    usrp_5: '''24-7_A.bin'''
    usrp_6: '''24-7_B.bin'''
    usrp_7: '''24-8_A.bin'''
    usrp_8: '''24-8_B.bin'''
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.6"'
    dev_args: '"dboard_clock_rate=20e6"'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    minoutbuf: '40000000'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sync: sync
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_2
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.5"'
    dev_args: '"dboard_clock_rate=20e6"'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    minoutbuf: '40000000'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_2_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.7"'
    dev_args: '"dboard_clock_rate=20e6"'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    minoutbuf: '40000000'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: none
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0_2_0_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: freq
    center_freq1: freq
    clock_source0: external
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: '"addr=10.10.24.8"'
    dev_args: '"dboard_clock_rate=20e6"'
    gain0: gain
    gain1: gain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    minoutbuf: '40000000'
    nchan: '2'
    norm_gain0: 'False'
    norm_gain1: 'False'
    samp_rate: samp_rate
    sd_spec0: A:0 B:0
    sync: none
    time_source0: external
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0_0_0, '0', epy_block_0, '2']
- [uhd_usrp_source_0_0_0, '0', epy_block_1, '2']
- [uhd_usrp_source_0_0_0, '1', epy_block_0, '3']
- [uhd_usrp_source_0_0_0, '1', epy_block_1, '3']
- [uhd_usrp_source_0_2, '0', epy_block_0, '0']
- [uhd_usrp_source_0_2, '0', epy_block_1, '0']
- [uhd_usrp_source_0_2, '0', qtgui_freq_sink_x_3, '0']
- [uhd_usrp_source_0_2, '1', epy_block_0, '1']
- [uhd_usrp_source_0_2, '1', epy_block_1, '1']
- [uhd_usrp_source_0_2_0, '0', epy_block_1, '4']
- [uhd_usrp_source_0_2_0, '1', epy_block_1, '5']
- [uhd_usrp_source_0_2_0_0, '0', epy_block_1, '6']
- [uhd_usrp_source_0_2_0_0, '1', epy_block_1, '7']

metadata:
  file_format: 1
